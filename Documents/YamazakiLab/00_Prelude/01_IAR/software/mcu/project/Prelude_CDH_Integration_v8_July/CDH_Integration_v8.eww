<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\reb1_va108xx.ewp</path>
  </project>
  <batchBuild/>
</workspace>
