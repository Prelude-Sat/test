# IAR project reb1_va108xx.ewp, settings and files
configuration reb1_va108xx (ARM, debug)
  General.OGChipSelectEditMenu: VA10800 Vorago VA10800
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: RTT_LOG; SKIP_UTILS
  ICCARM.CCIncludePath2: ../../Driver/hdr; ./hdr; ../../Utilities/hdr; ../../Common/hdr
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common
    ../../common/hdr/: cmsis_armcc.h core_cm0.h core_cmFunc.h core_cmInstr.h irq_va108xx.h system_va108xx.h va108xx.h
    ../../common/src/: hardfault_handler.c irq_va108xx.c system_va108xx.c
    ./: startup_IAR_va108xx.s
  group custom
    src/: integration_main.c pp_adc.c pp_i2c_a.c pp_i2c_b.c pp_spi_v2.0.c pp_timer_v2.0.c reb_adt75.c reb_log.c reb_max11619.c reb_timer.c sleep.c
    hdr/: mcp3208.h pp_adc.h pp_i2c_a.h pp_i2c_b.h pp_spi_v2.0.h pp_timer_v2.0.h reb_adt75.h reb_board.h reb_log.h reb_max11619.h reb_timer.h sleep.h
  group driver
    ../../driver/src/: driver.common.c gpio_drv_api.c gpio_va108xx.c i2c_drv_api.c i2c_va108xx.c spi_drv_api.c spi_va108xx.c uart_drv_api.c uart_va108xx.c
    ../../driver/hdr/: driver_common.h driver_gpio.h driver_i2c.h driver_spi.h driver_uart.h gpio_va108xx.h i2c_va108xx.h spi_va108xx.h uart_va108xx.h
  group utilities
    $EW_DIR$/arm/inc/c/: intrinsics.h
    ../../utilities/src/: redirect.c segger_rtt.c segger_rtt_printf.c SEGGER_RTT_Syscalls_IAR.c utils.c
    ../../utilities/hdr/: redirect.h segger_rtt.h segger_rtt_conf.h utils.h
