# Keil uVision project SPI_AN__va108xx.uvprojx, settings and files
target reb1_va108xx (5060020::V5.06 (build 20)::ARMCC)
  device: VA108xx Generic
  pack: Vorago.VA108xx.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x10000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: reb1_va108xx +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin #L --output $L@L.bin
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: RTT_LOG, SKIP_UTILS
  c include: ..\..\Driver\hdr;.\hdr;..\..\Utilities\hdr;..\..\Common\hdr
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  group common
    ../../common/hdr/: irq_va108xx.h cmsis_armcc.h core_cm0.h core_cmFunc.h core_cmInstr.h system_va108xx.h va108xx.h
    ../../common/src/: hardfault_handler.c irq_va108xx.c startup_va108xx.s system_va108xx.c
  group driver
    ../../driver/hdr/: driver_common.h driver_gpio.h driver_i2c.h driver_spi.h driver_uart.h gpio_va108xx.h i2c_va108xx.h spi_va108xx.h uart_va108xx.h
    ../../driver/src/: driver.common.c gpio_drv_api.c gpio_va108xx.c i2c_drv_api.c i2c_va108xx.c spi_drv_api.c spi_va108xx.c uart_drv_api.c uart_va108xx.c
  group custom
    ./hdr/: reb_adt75.h reb_board.h reb_log.h reb_max11619.h reb_timer.h
    ./src/: reb_adt75.c reb_log.c reb_max11619.c reb_timer.c SPI_AN_main.c
  group utilities
    ../../utilities/hdr/: redirect.h segger_rtt.h segger_rtt_conf.h utils.h
    ../../utilities/src/: redirect.c segger_rtt.c segger_rtt_printf.c segger_rtt_syscalls_keil.c utils.c
target SPI_AN_xx (5060020::V5.06 (build 20)::ARMCC)
  device: VA108xx Generic
  pack: Vorago.VA108xx.1.0.0
  cpu: as above
  output: reb1_va108xx +hex
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: RTT_LOG, SKIP_UTILS
  c include: ..\..\Driver\hdr;.\hdr;..\..\Utilities\hdr;..\..\Common\hdr
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
